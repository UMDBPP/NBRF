options:
  parameters:
    generate_options: qt_gui
    id: NBRF
    output_language: python
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 1000e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2400e6
  states: {}
- name: filename
  id: variable
  parameters:
    value: '"/home/pi/nbrf_folder/ns115/flight.bin"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: filename
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '0'
    bw0: bandwidth
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
