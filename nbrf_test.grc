options:
  parameters:
    generate_options: qt_gui
    id: NBRF
    output_language: python
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2400e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '0'
    bw0: bandwidth
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth
    fc: center_freq
    fftsize: '1024'
    type: complex
    update_time: '0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bandwidth
    fc: center_freq
    fftsize: '1024'
    type: complex
    update_time: '0.5'
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
